# Keil uVision project N32WB031_STB_HID_SWIPE_OLED.uvprojx, settings and files
target N32WB031_STB_HID_SWIPE_OLED (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: N32WB031_STB_HID_SWIPE_OLED
  AfterMake: fromelf --bin --output=.\bin\hid_mouse.bin .\Objects\hid_mouse.axf
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\core;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\device;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\n32wb03x_std_periph_driver\inc;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\adv;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\timer;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\log;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\delay;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\sleep;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\sec;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\ble;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\src
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_spi.c n32wb03x_keyscan.c n32wb03x_qflash.c
  group BLE_STACK
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
  group BLE_PROFILE
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/bas/bass/src/: bass.c bass_task.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/rdts/: rdts_common.c
  group NS_LIB
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/timer/: ns_timer.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/log/: ns_log_usart.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
  group BLE_APP
    ../src/app_profile/: app_dis.c app_batt.c app_hid.c
    ../src/: app_ble.c
  group USER
    ../src/: main.c app_gpio.c app_oled.c
  group CONFIG
    ../inc/: app_user_config.h
  group DOC
    ../: readme.txt
