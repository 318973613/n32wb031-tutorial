# Keil uVision project N32WB031_STB_Key_USART.uvprojx, settings and files
target N32WB031_STB_Key_USART (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: N32WB031_STB_Key_USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\core;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\device;..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\n32wb03x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/n32wb03x_std_periph_driver/src/: n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_usart.c
  group USER
    ../src/: main.c n32wb03x_it.c
  group DOC
    ../: readme.txt
