# Keil uVision project N32WB031_STB_OTA_MASTERBOOT.uvprojx, settings and files
target N32WB031_STB_OTA_MASTERBOOT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: N32WB031_STB_OTA_MASTERBOOT +hex
  AfterMake: fromelf --bin --output=.\bin\masterboot.bin .\Objects\masterboot.axf
  AfterMake: cmd.exe /C copy .\bin\masterboot.bin ..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\utilities\dfu\Image\MasterBoot.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03x, USE_STDPERIPH_DRIVER,MASTERBOOT
  c include: ..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\core;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\device;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\n32wb03x_std_periph_driver\inc;..\inc;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\error;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\dfu;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\scheduler;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x2000
  memory RVCT9: RAM 0x20004000 size 0x8000
  group STARTUP
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_crc.c n32wb03x_usart.c n32wb03x_qflash.c
  group USER
    ../src/: main.c
  group NS_LIB
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/error/: ns_error.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/scheduler/: ns_scheduler.c
  group DOC
    ../: readme.txt
  group NS_DFU
    ../../common/: dfu_usart.c dfu_led.c dfu_delay.c dfu_crc.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/dfu/: ns_dfu_boot.c ns_dfu_serial.c
