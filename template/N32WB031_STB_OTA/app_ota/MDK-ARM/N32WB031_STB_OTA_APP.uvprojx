# Keil uVision project N32WB031_STB_OTA_APP.uvprojx, settings and files
target N32WB031_STB_OTA_APP1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: N32WB031_STB_OTA_APP1 +hex
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03x, USE_STDPERIPH_DRIVER,APPLICATION
  c include: ..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\core;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\CMSIS\device;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\firmware\n32wb03x_std_periph_driver\inc;..\inc;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\log;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\adv;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\timer;..\inc\app_profile;..\inc\rw;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\dfu;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\ecc;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\error;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;..\..\common;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\delay;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\sleep;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\sec;..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_library\ble
  library: MicroLIB
  memory RVCT4: ROM 0x1004000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\..\..\..\sdk\N32WB03x_SDK_V2.0.0\N32WB03x_SDK_V2.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_crc.c n32wb03x_gpio.c n32wb03x_exti.c n32wb03x_pwr.c n32wb03x_rcc.c n32wb03x_qflash.c n32wb03x_lpuart.c
  group BLE_STACK
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip_driver.c rwip.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
  group BLE_PROFILE
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/ns_ius/ns_iuss/src/: ns_iuss.c ns_iuss_task.c
  group NS_LIB
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/log/: ns_log_lpuart.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/error/: ns_error.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/timer/: ns_timer.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
  group Crypto
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/ecc/: ns_ecc.c sha256.c uECC.c
  group NS_DFU
    ../../../../sdk/N32WB03x_SDK_V2.0.0/N32WB03x_SDK_V2.0.0/middlewares/Nationstech/ble_library/ns_library/dfu/: ns_dfu_ble.c ns_dfu_boot.c
    ../../common/: dfu_crc.c dfu_delay.c dfu_led.c
  group BLE_APP
    ../src/app_profile/: app_dis.c app_ns_ius.c
    ../src/: app_ble.c
  group USER
    ../src/: main.c
  group CONFIG
    ../inc/: app_user_config.h
  group DOC
    ../: readme.txt
target N32WB031_STB_OTA_APP2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.4.0
  cpu: as above
  output: N32WB031_STB_OTA_APP2 +hex
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03x, USE_STDPERIPH_DRIVER,APPLICATION
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1020000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: as above
